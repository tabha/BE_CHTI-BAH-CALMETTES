# Keil uVision project tdm.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tdm12
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c td_sub.s
  group Matlab
    ./Matlab/: Trigo.asm Signal.asm
  group Sys
    ./Sys/: startup-rvds.s
  group Lib
    ./: gfssp72.lib
software components: CMSIS:CORE 5.1.1
